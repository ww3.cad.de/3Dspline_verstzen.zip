# Autodesk Inventor part: 3Dspline_verstzen
## iProperties
Created: 2006-01
Part Number: 3Dspline_verstzen
Document SubType Name: Modeling
Designer: juergen
Author: juergen
